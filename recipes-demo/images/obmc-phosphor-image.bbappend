IMAGE_INSTALL += " demoapp"
